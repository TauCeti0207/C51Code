# Keil uVision project Project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Project1 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: Screen_lock_main.c lxl_24C02C.c LCD1602.c keypad44.c uart.c remember.txt
